# Keil uVision project WM.uvprojx, settings and files
target WM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WM +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC,USE_STM32F3_DISCO,
  c misc: --c99
  c include: Inc;Drivers\STM32F3xx_HAL_Driver\Inc;Drivers\BSP\STM32F3-Discovery;Drivers\CMSIS\Device\ST\STM32F3xx\Include;Drivers\CMSIS\Include;StartUp\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Doc
    ./Docs/: direct IO access.txt project directories.txt
  group HAL
    ./Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_spi.c stm32f3xx_hal_i2c.c
  group User
    ./Src/: main.cpp board.cpp motor.cpp seven_segment_display.cpp timer.cpp button.cpp door_button.cpp button_latch.cpp buzzer.cpp washing_machine.cpp stage.cpp program.cpp program_manager.cpp system_operator.cpp stage_data.cpp program_data.cpp
    ./Inc/: main.h board.h board_config.h pin_state.h seven_segment_display.h stm32f303_config_file.h motor.h timer.h timer_config_file.h button.h door_button.h button_state.h button_latch.h buzzer.h washing_machine.h stage.h stage_config.h stage_state.h stage_type.h mark_space_ratio.h program.h program_manager.h program_state.h system_operator.h stage_data.h program_data.h
  group BSP
    Drivers/BSP/STM32F3-Discovery/: stm32f3_discovery.c
  group StartUp
    ./StartUp/Src/: stm32f3xx_it.c system_stm32f3xx.c startup_stm32f303xc.s board_startup.c
software components: CMSIS:CORE 5.0.0
